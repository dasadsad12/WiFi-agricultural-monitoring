# Keil uVision project LoRa_Slave.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LORA-SLAVE +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ./startup/: startup_stm32f10x_md.s
  group USR
    ./user/: stm32f10x_it.c main.c delay.c OLED.c WifiRelay.c EnvFrame.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_usart.c
  group CMSYS
    ./user/: core_cm3.c system_stm32f10x.c
